## drivers/media/first_module/Kconfig
```kconfig
config FIRST_MODULE
	tristate "First module"
	depends on FIRST
	default n
	--- help ---
	First module made with Kconfig
```
